## arch/arm64/configs/misc_debug_defconfig
```kconfig
CONFIG_FRAME_WARN=0
CONFIG_KASAN=y
CONFIG_KASAN_INLINE=y
CONFIG_KCOV=y
CONFIG_KSU_MANUAL_HOOK=n
CONFIG_KSU_SUSFS=y
```
